## config/boards/shields/ikbc_c87_zmk_v2/Kconfig.shield
```kconfig
config SHIELD_IKBC_C87_ZMK_v2
    def_bool $(shields_list_contains,ikbc_c87_zmk_v2)
```
